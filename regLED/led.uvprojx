# Keil uVision project led.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.5
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\regLED
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: main.c startup_MM32SPIN2xx_p.s wy_gpio.c key.c
